# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users;.\app\gui;.\app\lcd;.\app\led
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_fsmc.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group app
    ./app/gui/: gui.c
    ./app/lcd/: lcd_driver.c
    ./app/led/: led.c
    ./app/qrcode/: qr_encode.c qr_encode.h
  group User
    ./Users/: main.c stm32f10x_it.c public.c
